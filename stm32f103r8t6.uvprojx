# Keil uVision project stm32f103r8t6.uvprojx, settings and files
target m3 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103r8t6
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\FWlib\inc;.\USER\delay;.\USER\dma;.\USER\led;.\USER\uart;.\USER\wifi;.\USER\key;.\USER;.\USER\STMFLASH;.\USER\wifi\HMACSHA1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./USER/: main.c
    ./USER/delay/: delay.c
    ./USER/led/: led.c
    ./USER/uart/: usart.c
    ./USER/wifi/: wifi.c
    ./USER/key/: key.c
    ./USER/STMFLASH/: stmflash.c
    ./USER/wifi/HMACSHA1/: hmacsha1.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group FWlib
    ./FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c
